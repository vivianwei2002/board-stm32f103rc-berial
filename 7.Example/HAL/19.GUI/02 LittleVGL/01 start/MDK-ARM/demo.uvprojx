# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Include;../Lib;../../Lib;../../Lib/lvgl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group lvgl/core
    ../../Lib/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/draw
    ../../Lib/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Lib/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../Lib/lvgl/src/draw/nxp/: lv_gpu_nxp.c
    ../../Lib/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../Lib/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../../Lib/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../Lib/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Lib/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Lib/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group lvgl/hal
    ../../Lib/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/layout
    ../../Lib/lvgl/src/layouts/flex/: lv_flex.c
    ../../Lib/lvgl/src/layouts/grid/: lv_grid.c
  group lvgl/widgets
    ../../Lib/lvgl/src/widgets/animimg/: lv_animimg.c
    ../../Lib/lvgl/src/widgets/arc/: lv_arc.c
    ../../Lib/lvgl/src/widgets/bar/: lv_bar.c
    ../../Lib/lvgl/src/widgets/btn/: lv_btn.c
    ../../Lib/lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../../Lib/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Lib/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Lib/lvgl/src/widgets/chart/: lv_chart.c
    ../../Lib/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Lib/lvgl/src/widgets/colorwheel/: lv_colorwheel.c
    ../../Lib/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Lib/lvgl/src/widgets/img/: lv_img.c
    ../../Lib/lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    ../../Lib/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Lib/lvgl/src/widgets/label/: lv_label.c
    ../../Lib/lvgl/src/widgets/led/: lv_led.c
    ../../Lib/lvgl/src/widgets/line/: lv_line.c
    ../../Lib/lvgl/src/widgets/list/: lv_list.c
    ../../Lib/lvgl/src/widgets/menu/: lv_menu.c
    ../../Lib/lvgl/src/widgets/meter/: lv_meter.c
    ../../Lib/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Lib/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Lib/lvgl/src/widgets/roller/: lv_roller.c
    ../../Lib/lvgl/src/widgets/slider/: lv_slider.c
    ../../Lib/lvgl/src/widgets/span/: lv_span.c
    ../../Lib/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Lib/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Lib/lvgl/src/widgets/switch/: lv_switch.c
    ../../Lib/lvgl/src/widgets/table/: lv_table.c
    ../../Lib/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Lib/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Lib/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Lib/lvgl/src/widgets/win/: lv_win.c
  group lvgl/misc
    ../../Lib/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/other
    ../../Lib/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Lib/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../Lib/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../Lib/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../Lib/lvgl/src/others/monkey/: lv_monkey.c
    ../../Lib/lvgl/src/others/msg/: lv_msg.c
  group lvgl/theme
    ../../Lib/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../Lib/lvgl/src/themes/basic/: lv_theme_basic.c
    ../../Lib/lvgl/src/themes/default/: lv_theme_default.c
    ../../Lib/lvgl/src/themes/mono/: lv_theme_mono.c
  group lvgl/port
    ../../Lib/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl/examples
    ../../Lib/lvgl/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_timeline_1.c
    ../../Lib/lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c img_caret_down.c img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c
    ../../Lib/lvgl/examples/assets/emoji/: img_emoji_F617.c
    ../../Lib/lvgl/examples/event/: lv_example_event_1.c lv_example_event_2.c lv_example_event_3.c lv_example_event_4.c
    ../../Lib/lvgl/examples/get_started/: lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c
    ../../Lib/lvgl/examples/layouts/flex/: lv_example_flex_1.c lv_example_flex_2.c lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c
    ../../Lib/lvgl/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_5.c lv_example_grid_6.c
    ../../Lib/lvgl/examples/libs/bmp/: lv_example_bmp_1.c
    ../../Lib/lvgl/examples/libs/ffmpeg/: lv_example_ffmpeg_1.c lv_example_ffmpeg_2.c
    ../../Lib/lvgl/examples/libs/freetype/: lv_example_freetype_1.c
    ../../Lib/lvgl/examples/libs/gif/: img_bulb_gif.c lv_example_gif_1.c
    ../../Lib/lvgl/examples/libs/png/: img_wink_png.c lv_example_png_1.c
    ../../Lib/lvgl/examples/libs/qrcode/: lv_example_qrcode_1.c
    ../../Lib/lvgl/examples/libs/rlottie/: lv_example_rlottie_1.c lv_example_rlottie_2.c lv_example_rlottie_approve.c
    ../../Lib/lvgl/examples/libs/sjpg/: lv_example_sjpg_1.c
    ../../Lib/lvgl/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
    ../../Lib/lvgl/examples/others/gridnav/: lv_example_gridnav_1.c lv_example_gridnav_2.c lv_example_gridnav_3.c lv_example_gridnav_4.c
    ../../Lib/lvgl/examples/others/ime/: lv_example_ime_pinyin_1.c lv_example_ime_pinyin_2.c
    ../../Lib/lvgl/examples/others/imgfont/: lv_example_imgfont_1.c
    ../../Lib/lvgl/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
    ../../Lib/lvgl/examples/others/msg/: lv_example_msg_1.c lv_example_msg_2.c lv_example_msg_3.c
    ../../Lib/lvgl/examples/others/snapshot/: lv_example_snapshot_1.c
    ../../Lib/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
    ../../Lib/lvgl/examples/scroll/: lv_example_scroll_1.c lv_example_scroll_2.c lv_example_scroll_3.c lv_example_scroll_4.c lv_example_scroll_5.c lv_example_scroll_6.c
    ../../Lib/lvgl/examples/styles/: lv_example_style_1.c lv_example_style_10.c lv_example_style_11.c lv_example_style_12.c lv_example_style_13.c lv_example_style_14.c lv_example_style_15.c lv_example_style_2.c lv_example_style_3.c lv_example_style_4.c lv_example_style_5.c lv_example_style_6.c lv_example_style_7.c lv_example_style_8.c lv_example_style_9.c
    ../../Lib/lvgl/examples/widgets/animimg/: lv_example_animimg_1.c
    ../../Lib/lvgl/examples/widgets/arc/: lv_example_arc_1.c lv_example_arc_2.c
    ../../Lib/lvgl/examples/widgets/bar/: lv_example_bar_1.c lv_example_bar_2.c lv_example_bar_3.c lv_example_bar_4.c lv_example_bar_5.c lv_example_bar_6.c
    ../../Lib/lvgl/examples/widgets/btn/: lv_example_btn_1.c lv_example_btn_2.c lv_example_btn_3.c
    ../../Lib/lvgl/examples/widgets/btnmatrix/: lv_example_btnmatrix_1.c lv_example_btnmatrix_2.c lv_example_btnmatrix_3.c
    ../../Lib/lvgl/examples/widgets/calendar/: lv_example_calendar_1.c
    ../../Lib/lvgl/examples/widgets/canvas/: lv_example_canvas_1.c lv_example_canvas_2.c
    ../../Lib/lvgl/examples/widgets/chart/: lv_example_chart_1.c lv_example_chart_2.c lv_example_chart_3.c lv_example_chart_4.c lv_example_chart_5.c lv_example_chart_6.c lv_example_chart_7.c lv_example_chart_8.c lv_example_chart_9.c
    ../../Lib/lvgl/examples/widgets/checkbox/: lv_example_checkbox_1.c lv_example_checkbox_2.c
    ../../Lib/lvgl/examples/widgets/colorwheel/: lv_example_colorwheel_1.c
    ../../Lib/lvgl/examples/widgets/dropdown/: lv_example_dropdown_1.c lv_example_dropdown_2.c lv_example_dropdown_3.c
    ../../Lib/lvgl/examples/widgets/img/: lv_example_img_1.c lv_example_img_2.c lv_example_img_3.c lv_example_img_4.c
    ../../Lib/lvgl/examples/widgets/imgbtn/: lv_example_imgbtn_1.c
    ../../Lib/lvgl/examples/widgets/keyboard/: lv_example_keyboard_1.c lv_example_keyboard_2.c
    ../../Lib/lvgl/examples/widgets/label/: lv_example_label_1.c lv_example_label_2.c lv_example_label_3.c lv_example_label_4.c lv_example_label_5.c
    ../../Lib/lvgl/examples/widgets/led/: lv_example_led_1.c
    ../../Lib/lvgl/examples/widgets/line/: lv_example_line_1.c
    ../../Lib/lvgl/examples/widgets/list/: lv_example_list_1.c lv_example_list_2.c
    ../../Lib/lvgl/examples/widgets/menu/: lv_example_menu_1.c lv_example_menu_2.c lv_example_menu_3.c lv_example_menu_4.c lv_example_menu_5.c
    ../../Lib/lvgl/examples/widgets/meter/: lv_example_meter_1.c lv_example_meter_2.c lv_example_meter_3.c lv_example_meter_4.c
    ../../Lib/lvgl/examples/widgets/msgbox/: lv_example_msgbox_1.c
    ../../Lib/lvgl/examples/widgets/obj/: lv_example_obj_1.c lv_example_obj_2.c
    ../../Lib/lvgl/examples/widgets/roller/: lv_example_roller_1.c lv_example_roller_2.c lv_example_roller_3.c
    ../../Lib/lvgl/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_2.c lv_example_slider_3.c
    ../../Lib/lvgl/examples/widgets/span/: lv_example_span_1.c
    ../../Lib/lvgl/examples/widgets/spinbox/: lv_example_spinbox_1.c
    ../../Lib/lvgl/examples/widgets/spinner/: lv_example_spinner_1.c
    ../../Lib/lvgl/examples/widgets/switch/: lv_example_switch_1.c
    ../../Lib/lvgl/examples/widgets/table/: lv_example_table_1.c lv_example_table_2.c
    ../../Lib/lvgl/examples/widgets/tabview/: lv_example_tabview_1.c lv_example_tabview_2.c
    ../../Lib/lvgl/examples/widgets/textarea/: lv_example_textarea_1.c lv_example_textarea_2.c lv_example_textarea_3.c
    ../../Lib/lvgl/examples/widgets/tileview/: lv_example_tileview_1.c
    ../../Lib/lvgl/examples/widgets/win/: lv_example_win_1.c
  group lvgl/font
    ../../Lib/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.5.0
